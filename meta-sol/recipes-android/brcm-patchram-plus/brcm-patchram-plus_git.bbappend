FILESEXTRAPATHS:prepend:sol := "${THISDIR}/brcm-patchram-plus:"
SRC_URI:append:sol = " file://patchram.service"
